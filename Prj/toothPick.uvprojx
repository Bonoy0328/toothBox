# Keil uVision project toothPick.uvprojx, settings and files
target toothPick (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L110C6UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: toothPick
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\driver\inc;.\mcu\common;.\source\inc;.\profile;.\freeRTos\inc;.\freeRTos\port\RVDS\ARM_CM0;.\freeRTos\port\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group common
    ./: startup_hc32l110.s
    ./mcu/common/: system_hc32l110.c
  group source
    ./source/: main.c timeTask.c halLayer.c
  group driver
    ./driver/src/: ddl.c interrupts_hc32l110.c clk.c gpio.c adc.c bt.c lpuart.c
  group profile
    ./profile/: MacDef.h GloVarReDef.h GloVarDef.h GloTypeDef.h FreeRTOSConfig.h
  group freeRTos
    ./freeRTos/: list.c queue.c tasks.c timers.c croutine.c event_groups.c stream_buffer.c
    ./freeRTos/port/MemMang/: heap_4.c
    ./freeRTos/port/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 5.3.0
